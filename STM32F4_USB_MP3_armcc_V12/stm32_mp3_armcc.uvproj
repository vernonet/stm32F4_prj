# Keil uVision project stm32_mp3_armcc.uvproj, settings and files
target in_Flash_armcc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32_mp3_v12_inFlash +hex
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99 --wchar32
  c include: .\inc;.\lib\USB_Host\Class\MSC;.\lib\helix;.\lib\helix\pub;.\lib\Drivers\STM32F4xx_HAL_Driver\Inc;.\lib\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\lib\Drivers\CMSIS\Include;.\lib\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\lib\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;.\lib\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;.\lib\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\lib\Middlewares\Third_Party\FatFs\src\option;.\lib\Drivers\BSP\STM32F4-Discovery;.\lib\Drivers\BSP\Components\cs43l22;.\lib\Middlewares\Third_Party\FatFs\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./src/: main.c stm32f4xx_it.c system_stm32f4xx.c usbh_conf.c startup_stm32f407xx.s
  group Audio
    ./src/: Audio.c
  group USB
    ./src/: usbh_diskio_dma.c
  group StdPeriph_HAL
    ./lib/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group USBhost_core_source
    ./lib/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group USBhost_class_source
    ./lib/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Fatfs_source
    ./lib/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c fattime.c
    ./lib/Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group helix_sorce
    ./lib/helix/: lib_helix.lib
  group helix_source_clang
    ./lib/helix/: mp3dec.c mp3tabs.c
    ./lib/helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
  group BSP
    ./lib/Drivers/BSP/Components/cs43l22/: cs43l22.c
    ./lib/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio.c stm32f4_discovery_accelerometer.c
    ./lib/Drivers/BSP/Components/lis3dsh/: lis3dsh.c
    ./lib/Drivers/BSP/Components/lis302dl/: lis302dl.c
target in_RAM_armcc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: stm32_mp3_RAM
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx, VECT_TAB_SRAM
  c misc: --C99 --wchar32
  c include: .\inc;.\lib\USB_Host\Class\MSC;.\lib\helix;.\lib\helix\pub;.\lib\Drivers\STM32F4xx_HAL_Driver\Inc;.\lib\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\lib\Drivers\CMSIS\Include;.\lib\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\lib\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;.\lib\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;.\lib\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\lib\Drivers\BSP\STM32F4-Discovery;.\lib\Drivers\BSP\Components\cs43l22;.\lib\Middlewares\Third_Party\FatFs\src
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32_mp3_v12_RAM.sct
  link misc: --diag_suppress=L6329
target in_RAM_clang (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: stm32_mp3_RAM_clang
  c flags: Optim=6 oTime=1 OneElfS=1 v6Lang=4 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx, VECT_TAB_SRAM
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32_mp3_v12_RAM_clang.sct
  link misc: --diag_suppress=L6329
