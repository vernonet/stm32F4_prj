# Keil uVision project inet_radio.uvproj, settings and files
target in_flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: radio_in_flash +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_DEFAULT_TIMEOUT_CALLBACK, STM32F40XX, FPM_ARM, ARM_ADS
  c misc: --wchar32
  c include: ..\..\project;..\..\cmsis;..\..\std-periph;..\..\std-periph\inc;..\..\usb-core\dev-driver;..\..\usb-core\otg-driver;..\..\usb-files;..\..\usb-files\rndis;..\..\lrndis\rndis-stm32;..\..\lrndis\dhcp-server;..\..\lrndis\dns-server;..\..\project\helix\pub;..\..\project\helix;..\..\project\helix\real;..\..\lrndis\LwIP\src\include;..\..\lrndis\LwIP\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\iradio\cpufw_in_flash_mod.sct
  group project
    ../../project/: app.c Interrupts.c Interrupts.h stm32f4xx_conf.h system_stm32f4xx.c startup_stm32f4xx.s time.c time.h stm32f4_discovery.c stm32f4_discovery.h Audio.c stm32f4_discovery_lis302dl.c
    ../../lrndis/LwIP/src/netif/: ethernet.c
  group usb-files
    ../../usb-files/: usb_bsp.c usbd_usr.c
  group usb-dev-core
    ../../usb-core/dev-driver/: usbd_req.h usbd_req.c usbd_ioreq.h usbd_def.h usbd_ioreq.c usbd_core.h usbd_core.c
  group usb-otg-core
    ../../usb-core/otg-driver/: usb_bsp.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h
  group std-periph
    ../../std-periph/src/: stm32f4xx_pwr.c stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_tim.c
  group Middlewares/LwIP/Core/IPv4
    ../../lrndis/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../lrndis/LwIP/src/core/: raw.c dns.c udp.c
  group Middlewares/LwIP/Api
    ../../lrndis/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lrndis/LwIP/src/core/: init.c netif.c pbuf.c tcp.c tcp_in.c tcp_out.c inet_chksum.c def.c ip.c mem.c memp.c sys.c timeouts.c stats.c
  group lrndis-stm32
    ../../lrndis/rndis-stm32/: usbd_rndis_core.h usbd_rndis_core.c rndis_protocol.h ndis.h usb_conf.h usbd_conf.h usbd_desc.c usbd_desc.h
  group helix
    ../../project/helix/: lib_helix.lib
  group helix_src_clang
    ../../project/helix/: mp3dec.c mp3tabs.c
    ../../project/helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../project/helix/real/arm/: asmpoly.S asmmisc.s
