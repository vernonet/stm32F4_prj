# Keil uVision project spi_prog.uvprojx, settings and files
target in_Flash_carm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_prog_2_14
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,  HSE_VALUE = 8000000, DRIVER_SPI_NUM =  2, DRIVER_SPI_BUS_SPEED =  657000, USE_LFN, RTE_DEVICE_FRAMEWORK_CLASSIC
  c include: .\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;.\Drivers\BSP\STM32F4-Discovery;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Inc\no_cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ./Src/: usb_device.c stm32f4xx_it.c usbd_desc.c stm32f4xx_hal_msp.c usbd_conf.c usbd_storage_if.c main.c usbd_storage.c
    ./Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
    ./Inc/no_cmsis/: RTE_Device.h
  group Drivers/CMSIS
    ./Src/: system_stm32f4xx.c
    ./: startup_stm32f407xx.s
  group Middlewares/USB_Device_Library
    ./Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ./Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group SPI_flash
    ./Src/: chip_drv.c ff.c ffunicode.c flashchips.c spi.c SPI_STM32F4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c
target in_Flash_clang (6120000::V6.12::.\ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: spi_prog_2_14 +hex
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\spi_prog_Flash_clang.sct
target in_Ram_carm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: spi_prog_2_14
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,  HSE_VALUE = 8000000, DRIVER_SPI_NUM =  2, DRIVER_SPI_BUS_SPEED =  657000, USE_LFN, VECT_TAB_SRAM, RTE_DEVICE_FRAMEWORK_CLASSIC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\spi_prog_RAM_cmsis_mod.sct
target in_Ram_clang (6120000::V6.12::.\ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: spi_prog_2_14
  c flags: as above
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\spi_prog_RAM_clang_mod.sct
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDOUT 1.2.0
